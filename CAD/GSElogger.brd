# Repository CREATE-ROCKET/Avi_ENGINE_1k_LOGGER

File README.md:

# GSE電装 ロガー

# ファイル構成
CAD: Eagle,KiCadファイル
analysis: ログ解析プログラム
src: 基板書き込みプログラム

# アナログ回路の詳細

## 推力測定

1つのセンサーに対応

[使用するロードセル](https://www.te.com/usa-en/product-FC2311-0000-0250-L.html)

センサー出力 → 作動増幅回路 (ゲイン:47) → ローパスフィルタ (500Hz, R = 3.3 kΩ, C = 0.1 μF) → ADC

## 圧力測定

4つのセンサーに対応

[使用するセンサー](https://www.bdsensors.de/fileadmin/user_upload/Download/Datenblaetter_datasheets/DB_DMK331P_E.pdf)

センサー出力 → 分圧回路 (ゲイン: 0.5) → ボルテージフォロワ → ローパスフィルタ (500Hz, R = 3.3 kΩ, C = 0.1 μF) → ADC

## 圧力測定 (以前使っていたもの、参考)

[DMK331Pのリンク](https://www.bdsensors.de/fileadmin/user_upload/Download/Datenblaetter_datasheets/DB_DMK331P_E.pdf)

本機は1つの測定用回路を搭載、**ただしこの回路は電源電圧が不足しており、上のPU5402用の回路で運用する**

電源電圧は12V, センサー出力は0-10V で運用

センサー出力 → 分圧回路 (ゲイン: 0.5) → ボルテージフォロワ → ローパスフィルタ (500Hz, R = 3.3 kΩ, C = 0.1 μF) → ADC

## 圧力測定 (より以前使っていたもの、参考)

[FSV-010MPのリンク](https://www.sayama.com/products/index.php/item?cell003=%E5%9C%A7%E5%8A%9B%E3%82%BB%E3%83%B3%E3%82%B5&cell004=%E3%82%B2%E3%83%BC%E3%82%B8%E5%9C%A7%EF%BC%88%E6%B6%B2%E4%BD%93%EF%BC%89&name=%E3%82%B2%E3%83%BC%E3%82%B8%E5%9C%A7%E8%A8%88+%E5%9C%A7%E5%8A%9B%E3%82%BB%E3%83%B3%E3%82%B5++FSV-010MP&id=3137&label=1)

本機は非搭載

電源電圧は12V, センサー出力は0-5V で運用

センサー出力 → ローパスフィルタ (500Hz, R = 3.3 kΩ, C = 0.1 μF) → ADC

## 温度測定

熱電対により測定、高温用が2つ、低温用が3つ

[使用するセンサー](https://akizukidenshi.com/catalog/g/gP-10160/)

| 温度(℃) | 温度(K) | 抵抗値(Ω) |
|---------|---------|-----------|
| 0       | 273.15  | 2.87E+04  |
| 30      | 303.15  | 8.27E+03  |
| 60      | 333.15  | 2.98E+03  |
| 90      | 363.15  | 1.27E+03  |

高温用の分圧抵抗は10kΩ、低温用の分圧抵抗は1kΩ 

## ADC
[MCP3208-BI/SL](https://www.digikey.jp/en/products/detail/microchip-technology/MCP3208-BI-SL/319444)を使用

# 解析プログラム

`analysis/analysis.py` が解析プログラム。`analysis/analysis.py`が存在するディレクトリにて `python analysis.py <inputfile.csv> <outputfile.csv>`を実行。

colabなどのnotebookで実行できるようにした「燃焼実験ログをグラフに.ipynb」も同梱しました（宮田）

## EAGLE design CAD/GSElogger.brd

Parts:
C1, C2: 47p; C0603
C3, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C25, C26, C27, C28, C29, C30, C31: 0.1u; C0603
C4, C6, C23: 0.33u; C0603
C5, C7, C24: 2.2u; C0603
IC1: ESP32-WROOM-32E_M113EH3200PS3Q; ESP32WROOM32EM113EH3200PS3Q0
IC2: FT232RL; SSOP28
IC3, IC5: MCP3208-BI_P; DIP781W56P254L1918H533Q16N
IC4, IC6, IC7, IC8, IC9, IC10: NJU77551F-TE1; SOT95P280X130-5N
J1: ZX62R-B-5P_30_; ZX62R-B-5P(30)
J2: DM3AT-SF-PEJM5; DM3ATSFPEJM5
JP1: PINHD-1X2; 1X02
LED_ERR: B2B-XH-A_LF__SN_; SHDR2W64P0X250_1X2_740X575X700
LED_LOG: B2B-XH-A_LF__SN_; SHDR2W64P0X250_1X2_740X575X700
LED_POW: B2B-XH-A_LF__SN_; SHDR2W64P0X250_1X2_740X575X700
LOADSELL: PINHD-1X4; 1X04
NJM7805S: 5v reg; NJM2391DL1-33
OSC1, OSC3: 22u; E2,5-6E
OSC2: 100u; E2,5-6E
PRS_1_1, PRS_1_2, PRS_1_3, PRS_1_4, PRS_2: PINHD-1X3; 1X03
PS1: NJM7812FA; TO254P500X1000X2170-3P
R1, R7, R8, R9, R10, R11, R12, R33: 10k; R0603
R2, R37: 10K; R0603
R3, R4, R6, R21, R22, R24, R25, R27, R28, R30, R31: 1k; R0603
R5, R20, R23, R26, R29, R32: 3.3k; R0603
R13, R14, R15, R16, R18: 100; R0603
R17, R19: 4.99k; R0603
R34, R35, R36: 66.7; R0603
SW_LOG: B2B-XH-A_LF__SN_; SHDR2W64P0X250_1X2_740X575X700
SW_POW: B2B-XH-A_LF__SN_; SHDR2W64P0X250_1X2_740X575X700
TH_H1, TH_H2: PINHD-1X2; 1X02
TH_L1, TH_L2, TH_L3: PINHD-1X2; 1X02
U$1, U$3, U$4: SS2040FL
U$2: 3v3 reg; NJM2391DL1-33
VAT1, VAT2: B2B-XH-A_LF__SN_; SHDR2W64P0X250_1X2_740X575X700

Connections:
12V: C24.2, C25.2, OSC3.+, PRS_2.1, PS1.3 (OUT), U$4.A
+3V3: C5.1, C31.2, IC1.2 (3V3), IC2.4 (VCCIO), IC2.17 (3V3OUT), J2.4 (VDD), R1.2, R2.2, R6.1, R7.2, R8.2, R9.2, R10.2, R33.2, R34.2, SW_LOG.1, U$1.A, U$2.OUT
+5V: C4.1, C7.1, C9.2, C10.2, C12.2, C16.2, C18.2, C21.2, C26.2, C28.2, C29.2, C30.2, IC3.15 (VREF), IC3.16 (VDD), IC4.5 (V+), IC5.15 (VREF), IC5.16 (VDD), IC6.5 (V+), IC7.5 (V+), IC8.5 (V+), IC9.5 (V+), IC10.5 (V+), LOADSELL.1, NJM7805S.OUT, OSC2.+, R11.1, R12.1, R13.1, R14.1, R15.1, U$1.K, U$2.IN, U$3.A
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.2, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, IC1.1 (GND_1), IC1.15 (GND_2), IC1.38 (GND_3), IC1.39 (GND_4), IC1.40 (GND_5), IC1.41 (GND_6), IC1.42 (GND_7), IC1.43 (GND_8), IC1.44 (GND_9), IC1.45 (GND_10), IC1.46 (GND_11), IC1.47 (GND_12), IC2.7 (GND), IC2.18 (GND), IC2.21 (GND), IC2.25 (GND), IC2.26 (TEST), IC3.6 (CH5), IC3.7 (CH6), IC3.8 (CH7), IC3.9 (DGND), IC3.14 (AGND), IC4.2 (V-), IC5.2 (CH1), IC5.7 (CH6), IC5.9 (DGND), IC5.14 (AGND), IC6.2 (V-), IC7.2 (V-), IC8.2 (V-), IC9.2 (V-), IC10.2 (V-), J1.5, J2.6 (VSS), JP1.2, LED_ERR.2, LED_LOG.2, LED_POW.2, LOADSELL.4, NJM7805S.GND, OSC1.-, OSC2.-, OSC3.-, PRS_1_1.2, PRS_1_2.2, PRS_1_3.2, PRS_1_4.2, PRS_2.2, PS1.2 (GND), R3.2, R17.2, R21.2, R24.2, R27.2, R30.2, R37.2, TH_H1.2, TH_H2.2, TH_L1.2, TH_L2.2, TH_L3.2, U$2.GND, VAT2.2
IO0: IC1.25 (IO0), IC2.2 (!DTR), R2.1
IO2: IC1.24 (IO2), J2.7 (DAT0), JP1.1, R6.2
IO4: IC1.26 (IO4), J2.8 (DAT1), R7.1
IO12: IC1.14 (IO12), J2.1 (DAT2), R33.1
IO13: IC1.16 (IO13), J2.2 (CD/DAT3), R10.1
IO14: IC1.13 (IO14), J2.5 (CLK), R8.1
IO15: IC1.23 (IO15), J2.3 (CMD), R9.1
LOADCELL: C15.2, IC5.1 (CH0), R20.1
MCPCS1: IC1.8 (IO32), IC5.10 (!CS!/SHDN)
MCPCS2: IC1.12 (IO27), IC3.10 (!CS!/SHDN)
MISO: IC1.10 (IO25), IC3.12 (DOUT), IC5.12 (DOUT)
MOSI: IC1.11 (IO26), IC3.11 (DIN), IC5.11 (DIN)
unnamed: IC4.3 (-INPUT), IC4.4 (OUTPUT), R5.2
unnamed: IC2.20 (VCC), J1.1
unnamed: C2.1, IC2.16 (USBDM), J1.2
unnamed: C1.1, IC2.15 (USBDP), J1.3
unnamed: IC4.1 (+INPUT), R3.1, R4.2
unnamed: IC6.1 (+INPUT), R21.1, R22.2
unnamed: PRS_1_1.3, R4.1
unnamed: PRS_1_2.3, R22.1
unnamed: IC6.3 (-INPUT), IC6.4 (OUTPUT), R23.2
unnamed: IC7.1 (+INPUT), R24.1, R25.2
unnamed: PRS_1_3.3, R25.1
unnamed: IC7.3 (-INPUT), IC7.4 (OUTPUT), R26.2
unnamed: IC8.1 (+INPUT), R27.1, R28.2
unnamed: PRS_1_4.3, R28.1
unnamed: IC8.3 (-INPUT), IC8.4 (OUTPUT), R29.2
unnamed: IC9.4 (OUTPUT), R19.1, R20.2
unnamed: VAT1.2, VAT2.1
unnamed: IC10.1 (+INPUT), R30.1, R31.2
unnamed: PRS_2.3, R31.1
unnamed: IC10.3 (-INPUT), IC10.4 (OUTPUT), R32.2
unnamed: SW_POW.2, VAT1.1
unnamed: LOADSELL.2, R16.1
unnamed: LED_POW.1, R34.1
unnamed: IC9.3 (-INPUT), R18.1, R19.2
unnamed: LOADSELL.3, R18.2
unnamed: LED_LOG.1, R35.1
unnamed: LED_ERR.1, R36.1
unnamed: IC9.1 (+INPUT), R16.2, R17.1
unnamed: IC1.30 (IO18), R35.2
unnamed: IC1.31 (IO19), R36.2
unnamed: IC1.33 (IO21), R37.1, SW_LOG.2
PRESSURE_1_1: C14.2, IC5.3 (CH2), R5.1
PRESSURE_1_2: C13.2, IC5.4 (CH3), R23.1
PRESSURE_1_3: C19.2, IC5.5 (CH4), R26.1
PRESSURE_1_4: C22.2, IC5.6 (CH5), R29.1
PRESSURE_2: C27.2, IC5.8 (CH7), R32.1
RTS: C3.1, IC1.3 (EN), IC2.3 (!RTS), R1.1
SCK: IC1.9 (IO33), IC3.13 (CLK), IC5.13 (CLK)
SERIAL_M2S: IC1.35 (TXD0), IC2.5 (RXD)
SERIAL_S2M: IC1.34 (RXD0), IC2.1 (TXD)
THERMO_H_1: IC3.1 (CH0), R11.2, TH_H2.1
THERMO_H_2: IC3.2 (CH1), R12.2, TH_H1.1
THERMO_L_1: IC3.3 (CH2), R13.2, TH_L3.1
THERMO_L_2: IC3.4 (CH3), R14.2, TH_L2.1
THERMO_L_3: IC3.5 (CH4), R15.2, TH_L1.1
V+: C6.1, C8.2, C11.2, C17.2, C20.2, C23.1, NJM7805S.IN, OSC1.+, PRS_1_1.1, PRS_1_2.1, PRS_1_3.1, PRS_1_4.1, PS1.1 (IN), SW_POW.1, U$3.K, U$4.K

Notes on the sheet:
書き込み時はこのピンヘッダを導通させてください。 それ以外の時は開放してください。

Board: 2 copper layers, 100.0 x 80.0 mm, 108 parts (0 on the bottom side), 62 nets.

## Commit log

2022-01-29 [add] sdio write
2022-02-10 [add] main.cpp cmd seection
2022-02-13 [add] mcp3208 library and unstable 1k logging
2022-05-18 [fix] stabilized sd 1k logging
2022-05-18 [fix] writeSD
2022-05-28 [add] SDIOLogWrapper but RTOS task fails compiling
2022-05-28 [add] stable logging
2022-05-28 [fix] code location
2022-05-29 [fix] stable logging
2022-08-23 ⚡️ ファイル名変更の関数を追加、ネームスペース化
2022-08-25 ✅ newとdeleteを使用したqueueの使用領域の削減の実装
2022-09-03 📝 add README.md
2022-11-01 🚑️ newに失敗したときの処理の追加、およびロギング始/終時にQueueを作成/削除するよう変更
2022-11-08 ✅Queueが埋まった際リブートしないよう変更、放置テスト通過
2022-11-21 ✨ 外部スイッチによるロギング開始・停止を実装
2023-03-07 add led err indicator
2023-03-29 add data analysis program
2023-04-07 ロードセル荷重試験による推力算出方法の変更
2023-04-11 新サーミスタに合わせプログラムを変更
2023-05-18 低温用・高温用サーミスタの数を実運用に合わせて変更
2023-05-19 バルブ基板からのH/L信号を記録する機能を追加
2023-05-19 温度計算を修正、バルブ基板の情報を解析に反映
2023-05-19 add .gitignore
2023-05-26 tqdmが必要ないようにコードを変更
2023-05-26 解析プログラムの実行方法を追加
2023-06-25 Update README Document
2023-06-27 SDカードに1秒ごとにファイル分割して書き込む機能を追加
2023-06-28 ファイル分割機能を追加
2023-06-29 update stable logging
2023-07-21 update parameter
2023-09-28 add 0 division error
2023-11-06 fix row1
2025-08-28 add notebook analysis file
    ジュピターノートブックなどでログの簡単なグラフが見えるファイルを作りました
2025-08-28 コメント、説明文を修正
2025-11-22 analysis.pyを新ロードセル対応版に修正
    遅くなってすいません。
    notebookだけでなくanalysis.pyも修正しました
